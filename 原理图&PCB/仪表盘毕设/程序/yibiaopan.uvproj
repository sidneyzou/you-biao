# Keil uVision project yibiaopan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: yibiaopan +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MAIN.c
  group source
    ./: 12864.C USER.c DS18B20.c 24C0X.c KEY.c PWM.c
  group head
    ./: 12864.h HEAD.h english_5x8_pixel.h DS18B20.h 24C0X.h KEY.h PWM.h
